# Add here whatever needed from Vendor's side
IMAGE_INSTALL:append = " "
require meta-hailo-soc/meta-hailo-bsp/recipes-core/images/core-image-hailo.bb

